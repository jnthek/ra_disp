options:
  parameters:
    author: jishnu
    generate_options: qt_gui
    id: read_pulsar_voltage
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: NFFT
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1650000'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '500'
    type: complex
    vlen: NFFT
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
    vlen: NFFT
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: NFFT
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: NFFT
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jishnu/ASTRO/Pulsar/vela.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'False'
    shift: 'True'
    type: float
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: NFFT
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/500
    fc: '0'
    fftsize: NFFT
    int_max: '150'
    int_min: '0'
    type: complex
  states: {}

connections:
- [blocks_integrate_xx_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_xx_0, '0', fft_vxx_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_1, '0']
- [blocks_throttle_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [blocks_wavfile_source_0, '1', blocks_stream_to_vector_0_0, '0']
- [fft_vxx_0, '0', blocks_multiply_xx_0, '0']
- [fft_vxx_1, '0', blocks_multiply_xx_0, '1']
- [fft_vxx_2, '0', blocks_integrate_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
